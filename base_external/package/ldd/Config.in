## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
    bool "ldd"
    help
      Enable kernel modules from Linux Device Drivers (LDD3).
```
